# Keil uVision project Project.uvprojx, settings and files
target STM32H743I-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,STM32H743xx,USE_STM32H743I_EVAL,USE_IOEXPANDER,USE_USB_HS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/LCD;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Utilities/Lcd_Trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Example/User
    ../Src/: waveplayer.c menu.c explorer.c stm32h7xx_it.c main.c usbh_conf.c usbh_diskio.c waverecorder.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_audio.c stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_sdram.c stm32h743i_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c usbh_core.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_sram.c stm32h7xx_hal_sai.c stm32h7xx_ll_usb.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_hcd.c stm32h7xx_hal_adc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_tim.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_exti.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group STM32_Audio\Addons\PDM\Lib
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
software components: CMSIS:CORE 4.3.0
