# IAR project USBD_AUDIO.ewp, settings and files
configuration STM32H747I-EVAL_USBD-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; STM32H747xx; USE_HAL_DRIVER; USE_USB_FS; CORE_CM7
  ICCARM.CCIncludePath2: ..\CM7\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_AUDIO.hex
  ILINK.IlinkOutputFile: STM32H7xx_CM7.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I-EVAL_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_CM4 ST STM32H747XI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; STM32H747xx; USE_HAL_DRIVER; CORE_CM4
  ICCARM.CCIncludePath2: ..\CM4\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Application/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Application/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c usbd_audio_if.c usbd_conf.c usbd_desc.c
  group Application/EWARM
    ./: startup_stm32h747xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_audio.c stm32h747i_eval_bus.c stm32h747i_eval_io.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_usb.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_IAR_wc32.a
  group Middlewares/STM32_USBD_Library/Class
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
