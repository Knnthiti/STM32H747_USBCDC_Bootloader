# Keil uVision project Project.uvprojx, settings and files
target STM32H747I_EVAL_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x24000000-0x2407FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H747I_EVAL_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY, STM32H747xx, USE_STM32H747I_EVAL,CORE_CM7,TS_MULTI_TOUCH_SUPPORTED
  c include: ../Common/Inc;../CM7/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/LCD;../../../../../Utilities/Fonts;../../../../../Utilities/CPU;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: STM32H747I_EVAL_CM7\Exe\STM32H747I_EVAL_CM7.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Example/User/CM7
    ../CM7/Src/: audio_play.c audio_record.c eeprom.c joystick.c main.c qspi.c potentiometer.c sdram.c sram.c sd.c lcd.c nor.c touchscreen.c stm32h7xx_it.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/m24lr64/: m24lr64.c
    ../../../../../Drivers/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sdram.c stm32h7xx_hal_flash.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_uart.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_nor.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sai.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_tim.c stm32h7xx_hal_sram.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_audio.c stm32h747i_eval_bus.c stm32h747i_eval_eeprom.c stm32h747i_eval_io.c stm32h747i_eval_lcd.c stm32h747i_eval_nor.c stm32h747i_eval_qspi.c stm32h747i_eval_sd.c stm32h747i_eval_sdram.c stm32h747i_eval_sram.c stm32h747i_eval_ts.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
target STM32H747I_EVAL_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IROM(0x8000000-0x81FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32H747I_EVAL_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY, STM32H747xx, USE_STM32H747I_EVAL,CORE_CM4,TS_MULTI_TOUCH_SUPPORTED
  c include: ../Common/Inc;../CM4/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Fonts;../../../../../Utilities/CPU;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 4.3.0
