# IAR project Project.ewp, settings and files
configuration STM32H747I_DISCO_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM4 ST STM32H747XI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM4
  ICCARM.CCIncludePath2: ..\CM4\Inc; ..\CM7\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-DISCO; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H747I_DISCO_CM4.hex
  ILINK.IlinkOutputFile: STM32H747I_DISCO_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Lib\libPDMFilter_CM7_IAR_wc32.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I_DISCO_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7; TS_MULTI_TOUCH_SUPPORTED
  ICCARM.CCIncludePath2: ..\CM7\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-DISCO; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: STM32H747I_DISCO_CM7.hex
  ILINK.IlinkOutputFile: STM32H747I_DISCO_CM7.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../Drivers/BSP/Components/nt35510/: nt35510.c nt35510_reg.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../Drivers/BSP/Components/ov9655/: ov9655.c ov9655_reg.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32H747I_DISCOVERY
    ../../../../../Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_audio.c stm32h747i_discovery_bus.c stm32h747i_discovery_camera.c stm32h747i_discovery_lcd.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32h747xx.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: analog_audio_record.c audio_play.c audio_record.c camera.c joystick.c lcd.c main.c qspi.c sd.c sdram.c stm32h7xx_it.c touchscreen.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
