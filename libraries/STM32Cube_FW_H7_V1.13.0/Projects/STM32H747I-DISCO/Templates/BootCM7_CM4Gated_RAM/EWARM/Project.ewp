# IAR project Project.ewp, settings and files
configuration STM32H747I_DISCO_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM4 ST STM32H747XI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM4; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM4\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-DISCO; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H747I_DISCO_CM4.bin
  ILINK.IlinkOutputFile: STM32H747I_DISCO_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I_DISCO_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM7\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-DISCO; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  OBJCOPY.OOCOutputFile: STM32H745I_DISCO_CM7.hex
  ILINK.IlinkOutputFile: STM32H747I_DISCO_CM7.out
  ILINK.IlinkKeepSymbols: cm4_code
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/nt35510/: nt35510.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../Drivers/BSP/Components/ov9655/: ov9655.c ov9655_reg.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32H747I_DISCO
    ../../../../../Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_audio.c stm32h747i_discovery_camera.c stm32h747i_discovery_lcd.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sd.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32h747xx.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
