# Keil uVision project App.uvprojx, settings and files
target STM32H747XI (6240000::V6.24::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08020000,0x000E0000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: App
  AfterMake: fromelf --bin --output=@L.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USER_VECT_TAB_ADDRESS ,VECT_TAB_OFFSET = 0x20000
  c include: ..\libraries\CMSIS\Core\Include;..\libraries\CMSIS\Device\ST\STM32H7xx\Include;..\libraries\CMSIS\Device\ST\STM32H7xx\Source\Templates\arm;..\libraries\CMSIS\Device\ST\STM32H7xx\Source\Templates;..\libraries\STM32H7xx_HAL_Driver\Inc;..\BPS\Inc;..\App\Inc
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\App.sct
  group StartUP
    ../libraries/CMSIS/Device/ST/STM32H7xx/Include/: stm32h7xx.h stm32h747xx.h system_stm32h7xx.h
    ../libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
    ../libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
  group STM32_LL_driver
    ../libraries/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_ll_bus.h stm32h7xx_ll_gpio.h stm32h7xx_ll_rcc.h stm32h7xx_ll_utils.h
    ../libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_gpio.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c
  group BPS
    ../BPS/Inc/: Clock_system.h
    ../BPS/Src/: Clock_system.c
  group App
    ../App/Inc/: main_App.h
    ../App/Src/: main_App.c
