# Keil uVision project Bootloader.uvprojx, settings and files
target STM32H747XIH6 (6240000::V6.24::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER ,USER_VECT_TAB_ADDRESS ,VECT_TAB_OFFSET = 0x20000
  c include: ..\libraries\CMSIS\Device\ST\STM32H7xx\Include;..\libraries\CMSIS\Device\ST\STM32H7xx\Source\Templates\arm;..\libraries\CMSIS\Device\ST\STM32H7xx\Source\Templates;..\libraries\STM32H7xx_HAL_Driver\Inc;..\BPS\Inc;..\App\Inc;..\libraries\USB_DEVICE\App;..\libraries\USB_DEVICE\Target;..\libraries\CMSIS\Core\Include;..\libraries\STM32_USB_Device_Library_V2\Class\CDC\Inc;..\libraries\STM32_USB_Device_Library_V2\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group StartUP
    ../libraries/CMSIS/Device/ST/STM32H7xx/Include/: stm32h7xx.h stm32h747xx.h system_stm32h7xx.h
    ../libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
    ../libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
  group stm32h7xx_ll_driver
    ../libraries/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_ll_bus.h stm32h7xx_ll_crc.h stm32h7xx_ll_dma.h stm32h7xx_ll_gpio.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_utils.h
    ../libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_crc.c stm32h7xx_ll_dma.c stm32h7xx_ll_gpio.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group stm32h7xx_hal_driver
    ../libraries/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal.h stm32h7xx_hal_cortex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_hsem.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_rcc.h stm32h7xx_hal_dma.h stm32h7xx_hal_conf.h
    ../libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_dma.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c
  group USB_CDC
    ../libraries/USB_DEVICE/App/: usb_device.c usb_device.h usbd_desc.c usbd_desc.h
    ../libraries/USB_DEVICE/Target/: usbd_conf.c usbd_conf.h
    ../libraries/STM32_USB_Device_Library_V2/Class/CDC/Inc/: usbd_cdc.h
    ../libraries/STM32_USB_Device_Library_V2/Class/CDC/Src/: usbd_cdc.c
    ../libraries/STM32_USB_Device_Library_V2/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../libraries/STM32_USB_Device_Library_V2/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group BPS
    ../BPS/Inc/: Bootloader.h Clock_system.h USB_CDC.h
    ../BPS/Src/: Bootloader.c Clock_system.c USB_CDC.c
  group App
    ../App/Inc/: main_Bootloader.h
    ../App/Src/: main_Bootloader.c
